# Keil uVision project verdsd.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: verdsd +hex
  c flags: Optimize=8 SizeSpeed=1
  group src
    ./: STARTUP.A51 digital_show.c main.c stepmotor.c servo.c ADC0804.c DAC0832.c IR.c uart.c
  group inc
    ./: digital_show.h stepmotor.h servo.h ADC0804.h DAC0832.h uart.h
